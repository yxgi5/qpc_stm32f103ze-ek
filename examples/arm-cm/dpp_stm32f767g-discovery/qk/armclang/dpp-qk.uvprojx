# Keil uVision project dpp-qk.uvprojx, settings and files
target dpp-dbg (6060000::V6.6::.\ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x8000000,0x100000) IROM2(0x200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qk.bin .\dbg\dpp-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\Apollo_STM32F767;..\..\..\..\..\3rd_party\Apollo_STM32F767\Drivers\BSP\Apollo_STM32F767;..\..\..\..\..\3rd_party\Apollo_STM32F767\Drivers\STM32F7xx_HAL_Driver\Inc
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c main.c
    ../../: dpp.h bsp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group stm32f7-discovery
    ../../../../../3rd_party/Apollo_STM32F767/arm/: startup_stm32f767xx.s
    ../../../../../3rd_party/Apollo_STM32F767/: stm32f7xx.h stm32f767xx.h system_stm32f7xx.h system_stm32f7xx.c
    ../../../../../3rd_party/Apollo_STM32F767/Drivers/BSP/Apollo_STM32F767/: Apollo_STM32F767.h Apollo_STM32F767.c
    ../../: stm32f7xx_hal_conf.h stm32f7xx_hal_msp.c
  group STM32F7xx_HAL_Driver
    ../../../../../3rd_party/Apollo_STM32F767/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm-cm/qk/armclang/: qk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
target dbg-rel (6060000::V6.6::.\ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qk.bin .\rel\dpp-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
target dbg-spy (6060000::V6.6::.\ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qk.bin .\spy\dpp-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
